# Keil uVision project Remote.uvproj, settings and files
target Remote (MCS-51)
  device: STC15W4K32S4 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: Remote +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Common\inc;.\Driver\inc;.\BSP;.\Appcode;.\Startup
  group appcode
    ./Appcode/: isr.c main.c display.c
  group bsp
    ./BSP/: IAP15W4K61S4.h IOConfig.h
  group common
    ./Common/src/: led.c nrf24l0102.c oled.c battery.c
  group dirver
    ./Driver/src/: adc.c delay.c gpio.c timer.c uart.c
  group startup
    ./Startup/: STARTUP.A51
